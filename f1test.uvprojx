# Keil uVision project f1test.uvprojx, settings and files
target Target1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: f1test
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\FWLib1;.\FWLib1\core;.\FWLib1\inc;.\F1Lib;.\Driver;.\User;.\Software
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ./FWLib1/core/: startup_stm32f10x_md.s
  group Driver
    ./Driver/: SPIFlash.cpp
  group F1Lib
    ./F1Lib/: ADC.cpp GPIO.cpp HAL_F1.cpp HAL_F1_INT.cpp SPIDriver.cpp StmFlash.cpp TIMER.cpp USART.cpp
  group FW1Lib
    ./FWLib1/src/: misc.c stm32f10x_adc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group Software
    ./Software/: ftoa_engine.cpp Parameter.cpp Scheduler.cpp ultoa_invert.cpp
  group User
    ./User/: sys.c delay.c retargeting.cpp main.cpp
    ./FWLib1/: system_stm32f10x.c
